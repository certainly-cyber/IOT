# Keil uVision project IIC.uvprojx, settings and files
target Pragram (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Pargram +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\APP\APP\inc;..\APP\BLL;..\APP\DRL;..\APP\FML;..\APP\HAL;..\SYSTEM\delay;..\TIMER;..\OLED;..\HY-SRC50;..\EXTI;..\KEY;..\LED
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/delay/: delay.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_exti.c
  group APP/App
    ../APP/APP/src/: my_app.c
  group APP/Drl
    ../APP/DRL/: lmt70.c mcp3421.c
  group APP/Hal
    ../APP/HAL/: port_debug.c port_delay.c port_iic.c
  group hardware
    ../TIMER/: timer.c
    ../OLED/: oled.c
    ../HY-SRC50/: distimer.c
    ../EXTI/: exti.c
    ../KEY/: key.c
    ../LED/: led.c
